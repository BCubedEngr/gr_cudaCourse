options:
  parameters:
    generate_options: no_gui
    id: cudaFilterTest
    output_language: python
    run_options: run
    title: Cuda Filter Test
  states: {}

blocks:
- name: chunk_size
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: decimation
  id: variable
  parameters:
    value: '2'
  states: {}
- name: num_input_items
  id: variable
  parameters:
    value: samp_rate * 1000
  states: {}
- name: num_output_items
  id: variable
  parameters:
    value: num_input_items//decimation
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 32 * chunk_size
  states: {}
- name: variable_low_pass_filter_taps_0
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate/8
    gain: '1.0'
    samp_rate: samp_rate
    width: samp_rate/16
    win: window.WIN_HAMMING
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '1000'
    minoutbuf: 128*chunk_size
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    minoutbuf: 128*chunk_size
    num_items: num_input_items
    type: complex
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    minoutbuf: 128*chunk_size
    mintime: '500.0'
    type: complex
  states: {}
- name: cudaCourse_cudaDecimatingFirFilter_0
  id: cudaCourse_cudaDecimatingFirFilter
  parameters:
    blockSize: '256'
    chunkSize: (4 * chunk_size)//decimation
    decimationFactor: decimation
    minoutbuf: 64*chunk_size
    taps: variable_low_pass_filter_taps_0
  states: {}
- name: snippet_0
  id: snippet
  parameters:
    code: self.blocks_head_0.set_output_multiple((4*self.chunk_size)//self.decimation)
    section: main_after_init
  states: {}

connections:
- [analog_sig_source_x_0, '0', blocks_head_0, '0']
- [blocks_head_0, '0', cudaCourse_cudaDecimatingFirFilter_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [cudaCourse_cudaDecimatingFirFilter_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
